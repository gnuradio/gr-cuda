options:
  parameters:
    author: Josh Morman
    copyright: '2021'
    description: Example of using CUDA copy block
    generate_options: no_gui
    id: cuda_load
    output_language: python
    run_options: run
    title: CUDA Kernel Load Simulation Example
  states: {}

blocks:
- name: iterations
  id: variable
  parameters:
    value: '100'
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: use_cb
  id: variable
  parameters:
    comment: |-
      By setting this to False simulate the additional 
      ingress/egress incurred by not having custom buffers
    value: 'False'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_samples
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: cuda_load_0
  id: cuda_load
  parameters:
    iterations: iterations
    type: complex
    use_cb: use_cb
    vlen: '1'
  states: {}
- name: cuda_load_0_0
  id: cuda_load
  parameters:
    iterations: iterations
    type: complex
    use_cb: use_cb
    vlen: '1'
  states: {}
- name: cuda_load_0_1
  id: cuda_load
  parameters:
    iterations: iterations
    type: complex
    use_cb: use_cb
    vlen: '1'
  states: {}
- name: cuda_load_0_3
  id: cuda_load
  parameters:
    iterations: iterations
    type: complex
    use_cb: use_cb
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: note_0
  id: note
  parameters: {}
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.startt = time.time()
    section: main_after_init
  states: {}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      self.endt = time.time()
      print(f'Execution Time: {self.endt-self.startt} seconds')

      # sleep so the result shows up in the terminal
      time.sleep(2)
    section: main_after_stop
  states: {}

connections:
- [blocks_head_0, '0', blocks_null_sink_0, '0']
- [blocks_null_source_0, '0', cuda_load_0, '0']
- [cuda_load_0, '0', cuda_load_0_0, '0']
- [cuda_load_0_0, '0', cuda_load_0_1, '0']
- [cuda_load_0_1, '0', cuda_load_0_3, '0']
- [cuda_load_0_3, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
