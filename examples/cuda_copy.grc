options:
  parameters:
    author: Josh Morman
    copyright: '2021'
    description: Example of using CUDA copy block
    generate_options: qt_gui
    id: cuda_copy
    output_language: python
    title: CUDA Copy Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1234'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: cuda_copy_0
  id: cuda_copy
  parameters:
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: cuda_load_0
  id: cuda_load
  parameters:
    iterations: '1000'
    type: complex
    use_cb: 'False'
    vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '102400'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', cuda_copy_0, '0']
- [analog_sig_source_x_0, '0', cuda_load_0, '0']
- [cuda_copy_0, '0', qtgui_time_sink_x_0, '0']
- [cuda_load_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
