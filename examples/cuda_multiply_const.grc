options:
  parameters:
    author: Josh Morman
    copyright: '2021'
    description: Example of using CUDA copy block
    generate_options: qt_gui
    id: cuda_multiply_const
    output_language: python
    title: CUDA Multiply Const Example
  states: {}

blocks:
- name: k
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1234'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: cuda_multiply_const_xx_0
  id: cuda_multiply_const_xx
  parameters:
    const: k
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', cuda_multiply_const_xx_0, '0']
- [blocks_copy_0, '0', qtgui_time_sink_x_0, '0']
- [cuda_multiply_const_xx_0, '0', blocks_copy_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-310-g66696bf2
